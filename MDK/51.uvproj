# Keil uVision project 51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP;..\BSP\bsp_key;..\USER;..\BSP\bsp_lcd1602;..\middleware;..\middleware\EventHandler;..\BSP\DS1302;..\USER\timer
  group USER
    ./: STARTUP.A51
    ../USER/: main.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/bsp_lcd1602/: lcd1602.c
    ../BSP/DS1302/: ds1302.c
    ../USER/timer/: timer.c
    ../BSP/bsp_key/: bsp_key.c
  group middleware
    ../middleware/EventHandler/: EventHandler.c
